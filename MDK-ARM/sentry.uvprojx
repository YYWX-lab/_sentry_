# Keil uVision project sentry.uvprojx, settings and files
target Infantry (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../Components/utils;../Components/drvices;../Components/algorithms;../Components/Comm;../Components/SoftwareTimer;../Application;../MY_Task;../Application/chassis;../Components/drvices/Buzzer;../Components/drvices/RGB_Led;../Components/drvices/IMU;../Components/drvices/Motor;../Components/drvices/RemoteControl;../Application/gimbal;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/Src/: bsp_can.c bsp_delay.c bsp_flash.c bsp_gpio.c bsp_i2c.c bsp_init.c bsp_uart.c
  group Components/algorithms
    ../Components/algorithms/: AHRS_middleware.c pid.c ramp.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib
  group Components/Comm
    ../Components/Comm/: comm_protocol.c crc.c referee_system.c user_protocol.c client_ui_base.c
  group Components/drvices
    ../Components/drvices/Buzzer/: buzzer.c
    ../Components/drvices/IMU/: BMI088driver.c BMI088Middleware.c imu_driver.c ist8310driver.c ist8310driver_middleware.c
    ../Components/drvices/Motor/: blocked.c motor.c dm_motor_ctrl.c dm_motor_drv.c
    ../Components/drvices/RemoteControl/: remote_control.c
    ../Components/drvices/RGB_Led/: rgb_led.c super_power.c
  group Components/Software Timer
    ../Components/SoftwareTimer/: soft_timer.c
  group Components/utils
    ../Components/utils/: fifo.c
  group Application
    ../Application/: timer_task.c start_task.c infantry_console.c imu_task.c detect_task.c comm_task.c app_init.c calibrate.c clinet_ui_app.c
  group Application/gimbal
    ../Application/gimbal/: gimbal_app.c gimbal_function.c gimbal_task.c shoot_task.c dm_motor.c
  group Application/chassis
    ../Application/chassis/: chassis_app.c chassis_function.c chassis_task.c
  group MY_Task
    ../MY_Task/: data_send_task.c data_send_task.h MY_protocol.c MY_protocol.h MY_protocol_configuration.h RV_protocol.c RV_task.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
