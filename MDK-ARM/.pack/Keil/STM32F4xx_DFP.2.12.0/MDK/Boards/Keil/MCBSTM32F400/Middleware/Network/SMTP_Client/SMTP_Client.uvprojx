# Keil uVision project SMTP_Client.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SMTP_Client
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c SMTP_Client.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: as above
  output: SMTP_Client
  c flags: Optim=4
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.2.0, CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.2.3, Compiler:Event Recorder 1.2.1, Compiler:I/O:STDOUT 1.2.1, Board Support:A/D Converter 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Network:CORE 7.7.0, Network:CORE 7.7.0, Network:Interface:ETH 7.7.0, Network:Service:DNS Client 7.7.0, Network:Service:SMTP Client 7.7.0, Network:Socket:TCP 7.7.0, Network:Socket:UDP 7.7.0, CMSIS Driver:Ethernet MAC 2.8, Device:STM32Cube Framework:Classic 1.7.3, Device:STM32Cube HAL:ADC 1.7.3, Device:STM32Cube HAL:Common 1.7.3, Device:STM32Cube HAL:Cortex 1.7.3, Device:STM32Cube HAL:DMA 1.7.3, Device:STM32Cube HAL:GPIO 1.7.3, Device:STM32Cube HAL:PWR 1.7.3, Device:STM32Cube HAL:RCC 1.7.3, Device:STM32Cube HAL:SRAM 1.7.3, Device:Startup 2.6.2
