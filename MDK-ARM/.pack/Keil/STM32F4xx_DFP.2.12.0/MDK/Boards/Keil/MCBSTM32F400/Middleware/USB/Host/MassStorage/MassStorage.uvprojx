# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c MassStorage.c USBH_MSC.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: as above
  output: MassStorage
  c flags: Optim=4
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.2.3, Compiler:Event Recorder 1.2.1, Compiler:I/O:File 1.2.1, File System:CORE 6.10.0, File System:Drive:USB 6.10.0, USB:CORE 6.12.0, USB:CORE 6.12.0, USB:Host 6.12.0, USB:Host:MSC 6.12.0, CMSIS Driver:USB Host:Full-speed 2.21, CMSIS Driver:USB Host:High-speed 2.22, Device:STM32Cube Framework:Classic 1.7.3, Device:STM32Cube HAL:Common 1.7.3, Device:STM32Cube HAL:Cortex 1.7.3, Device:STM32Cube HAL:DMA 1.7.3, Device:STM32Cube HAL:GPIO 1.7.3, Device:STM32Cube HAL:PWR 1.7.3, Device:STM32Cube HAL:RCC 1.7.3, Device:STM32Cube HAL:SRAM 1.7.3, Device:Startup 2.6.2
